# SPDX-License-Identifier: MIT
# weston-simple-* and demo clients for board GUI validation.
PACKAGECONFIG:append:opentina-hmi = " clients"
